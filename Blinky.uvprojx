# Keil uVision project Blinky.uvprojx, settings and files
target LPC1768 Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress 550
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\DMA.sct
  group StartUp
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: GLCD_SPI_LPC1700.c LED.c IRQ.c Blinky.c KBD.c KBD.h GLCD.h photo_gallery.c game.c photos.c photos.h snake.c snake.h blackjack.c
  group Documentation
    ./: Abstract.txt
  group Pictures
    ./images/: fortnite.c sonar.c dick.c notes.c
  group audio
    ./audio/: usbuser.c adcuser.c core_cm3.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.h adcuser.h audio.h core_cm3.h LPC17xx.h type.h usb.h usbaudio.h usbcfg.h usbcore.h usbdesc.h usbhw.h usbreg.h
    ./: usbdmain.h
software components: CMSIS:CORE 5.4.0
